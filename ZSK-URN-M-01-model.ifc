Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:08+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-URN-M-01
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-URN-M-01 Урна «Квадро» · мрамор «шахматка»
In: Площадка
Description: Изделие бетонное благоустройства. Урна «Квадро» · мрамор «шахматка»; Classification: 59.1.15.02-0567 Урна (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-URN-M-01; ModelReference: Урна «Квадро» · мрамор «шахматка»; ProductionYear: 2026; ArticleNumber: ZSK-URN-M-01
ORION_Изделие - Артикул: ZSK-URN-M-01; Артикул прежний: SD-URN-M-01; Наименование: Урна «Квадро» · мрамор «шахматка»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 400×400 мм · высота 600 мм; Материал: Бетон; Цена: 36 800 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20102; Код КСИ: CPr>EDD250; Класс КСИ: Урна; Коды КСР: 59.1.15.02-0567 … 59.1.15.02-0579
ADSK - ADSK_Наименование: Урна «Квадро» · мрамор «шахматка»; ADSK_Марка: ZSK-URN-M-01; ADSK_Код изделия: 59.1.15.02-0567; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20102
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDD250; ZSK_Артикул_прежний: SD-URN-M-01
Qto_ORION - Длина: 400 mm; Ширина: 400 mm; Высота: 600 mm
